# Keil uVision project CMSIS-RTOS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CMSIS-RTOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./RTE/Device/STM32F303VCTx/STCubeGenerated/Src/: st_fake_tick.c koibitoex_lcd2.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F303VCTx/STCubeGenerated/Src/: main.c stm32f3xx_it.c
    ./RTE/Device/STM32F303VCTx/STCubeGenerated/Inc/: stm32f3xx_it.h
software components: CMSIS:CORE 5.2.0, CMSIS:RTOS2:Keil RTX5 5.5.0, Compiler:Event Recorder 1.4.0, Device:STM32Cube HAL 1.9.0
